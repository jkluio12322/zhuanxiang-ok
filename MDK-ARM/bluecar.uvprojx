# Keil uVision project bluecar.uvprojx, settings and files
target bluecar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bluecar +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Core/Application/Communication;../Core/Application/Control;../Core/Application/Config;../Core/Application/Display;../Core/Application/Motion;../Core/Application/Scheduler;../Core/Application/State;../Core/Hardware/Buffers;../Core/Hardware/Peripherals/Motion;../Core/Hardware/Peripherals/Sensors;../Core/Hardware/Peripherals/Display;../Core/Hardware/Peripherals/IO;../Core/Hardware/System;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/Communication
    ../Core/Application/Communication/: app_cmd.c app_telemetry.c app_console.c app_serial.c bytestream.c
  group Application/Control
    ../Core/Application/Control/: app_tracking.c app_pid.c app_testmode.c
  group Application/Scheduler
    ../Core/Application/Scheduler/: app_scheduler.c
  group Application/State
    ../Core/Application/State/: app_state.c app_imu.c
  group Application/Motion
    ../Core/Application/Motion/: app_motion.c app_speedloop.c
  group Application/Config
    ../Core/Application/Config/: app_config.h app_types.h board.h
  group Application/Display
    ../Core/Application/Display/: yingYongXianShi.c
  group Hardware/Buffers
    ../Core/Hardware/Buffers/: ringbuf.c
  group Hardware/Peripherals/Motion
    ../Core/Hardware/Peripherals/Motion/: motor.c encoder.c
  group Hardware/Peripherals/Sensors
    ../Core/Hardware/Peripherals/Sensors/: irtrack.c mpu6050.c filter.c
  group Hardware/Peripherals/Display
    ../Core/Hardware/Peripherals/Display/: oled.c oled_font.h oled_font_small.h
  group Hardware/Peripherals/IO
    ../Core/Hardware/Peripherals/IO/: key.c buzzer.c
  group Hardware/System
    ../Core/Hardware/System/: timer.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
